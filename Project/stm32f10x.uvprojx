# Keil uVision project stm32f10x.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ebox_v1_0 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,HSE_VALUE=8000000
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\ebox;..\ebox\core;..\ebox\Peripherals;..\edriver;..\network;..\fat;..\os;..\user
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group start_code
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group libraries
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ebox
    ../ebox/core/: core.cpp digital.cpp analog.cpp
    ../ebox/Peripherals/: uartx.cpp i2c.cpp softi2c.cpp SPI.cpp softspi.cpp exti.cpp pwm.cpp gtimer.cpp timerOne.cpp rtc.cpp
  group edriver
    ../edriver/: 74HC595.cpp Button.cpp DS3231.cpp encoder.cpp LCD1602.cpp LED.cpp MPU6050.CPP w25x16.cpp w5500.cpp mmc_sd.cpp
  group network
    ../network/: socket.cpp udp.cpp tcp.cpp
  group fat
    ../fat/: wrapperdiskio.cpp diskio.c ff.c
  group os
    ../os/: cpu.c cpu.h os.c os.h os_cpu_a.asm
  group user
    ../ebox/: ioconfig.cpp
    ../user/: stm32f10x_it.c main.cpp app1.cpp app2.cpp app3.cpp ctrpro.cpp
